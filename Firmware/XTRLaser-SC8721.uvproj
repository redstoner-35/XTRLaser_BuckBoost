# Keil uVision project XTRLaser-SC8721.uvproj, settings and files
target XTRLaser (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: XTRLaser-SC8721 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: AutoLockTimeOut=1200
  c include: .\StdDriver\inc;.\Hardware;.\include\Hardware;.\include\System;.\include\Middleware;.\include\Logic
  group User
    ./: STARTUP_CMS8S6990.A51 main.c
  group StdLib
    ./StdDriver/src/: gpio.c SysReset.c i2c.c
  group Hardware
    ./Hardware/: PinDefs.h ADCCfg.c delay.c Flash.c LEDMgmt.c PWM.c SideKey.c NTC.c
  group Middleware
    ./MiddleWare/: BattVoltDisplay.c SysConfig.c LVDCtrl.c OutputChannel.c
  group Logic
    ./Logic/: TempControl.c LowVoltageProt.c BreathMode.c Beacon.c SOS.c VersionCheck.c ActiveBeacon.c Sleep.c ModeControl.c SelfTest.c
